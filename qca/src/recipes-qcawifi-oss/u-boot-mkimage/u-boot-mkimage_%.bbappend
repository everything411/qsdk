LICENSE = "GPL-2.0+"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://01-increase_file_path_and_dtb_size.patch \
	   "
