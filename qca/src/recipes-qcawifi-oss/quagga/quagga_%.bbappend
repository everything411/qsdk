EXTRA_OECONF_remove= " \
    --disable-bgpd --disable-watchquagga \
    --disable-ospfd --disable-ospf6d --disable-ospfclient \
    --localstatedir=/var/run \
"
