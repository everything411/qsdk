EXTRA_OECONF += "bash_cv_getcwd_malloc=yes"
